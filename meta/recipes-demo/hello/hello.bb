DSC_URI = "http://ftp.de.debian.org/debian/pool/main/h/hello/hello_2.9-2+deb8u1.dsc;md5sum=faa827e0ff1d7e76c12488ed77e8fc76"

inherit debian-dsc
